# Keil uVision project Balance_Down.uvprojx, settings and files
target Balance_Down (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Balance_Down +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__CC_ARM,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1U
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application/AlgorithmLayer;../Application/ConfigLayer;../Application/DeviceLayer/Imu;../Application/DeviceLayer/Sensor;../Application/DeviceLayer/Key;../Application/DeviceLayer;../Application/DriverLayer;../Application/HardwareLayer/rp_motor_pack;../Application/ModuleLayer;../Application/ProtocolLayer;../Application/DeviceLayer/Motor;../Application/DeviceLayer/TOF;../Application/DeviceLayer/Judge;../Application/DeviceLayer/Super
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group algorithm
    ../Application/AlgorithmLayer/: rp_math.c ave_filter.c kalman_filter.c crc.c power_limit.c algo.h
  group config
    ../Application/ConfigLayer/: rp_config.c rp_config.h rp_device_config.h rp_driver_config.h rp_user_config.h
  group task
    ../Application/TaskLayer/: control_task.c heartbeat_task.c UI_Task.c
  group module
    ../Application/ModuleLayer/: chassic.c chassic.h Master_Comm.c Master_Comm.h State.c State.h UI.c UI.h offline.c offline.h LED.c LED.h module.h
  group protocol
    ../Application/ProtocolLayer/: rc_protocol.c imu_protocol.c can_protocol.c comm_protocol.c TOF_protocol.c judge_potocol.c cap_protocol.c
  group device/imu
    ../Application/DeviceLayer/Imu/: BMI.c bmi2.c bmi270.c common.c
  group device
    ../Application/DeviceLayer/Sensor/: imu_sensor.c rc_sensor.c
    ../Application/DeviceLayer/Key/: key_sensor.c
    ../Application/DeviceLayer/: user_motor.c device.c
    ../Application/DeviceLayer/TOF/: TOF_sensor.c
    ../Application/DeviceLayer/Judge/: judge_sensor.c
    ../Application/DeviceLayer/Super/: super.c
  group hardware
    ../Application/HardwareLayer/rp_motor_pack/: KT_motor.c RM_motor.c motor_def.h
  group driver
    ../Application/DriverLayer/: driver.c drv_can.c drv_spi.c drv_tick.c drv_tim.c drv_uart.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2
